# Keil uVision project bootloader.uvproj, settings and files
target Target 1 (MCS-51)
  device: FU6815 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: bootloader +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Library\Core;.\User;.\Library\Core
  asm include: .\User
  link misc: REMOVEUNUSED
  group Source Group 1
    ./User/: main.c STARTUP.A51
